# Keil uVision project Mini project testing.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Mini project testing +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=4
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: main.c RCC_config.h RCC_interface.h RCC_private.h RCC_program.c SCB_config.h SCB_interface.h SCB_private.h SCB_program.c STD_TYPES.h SYSTICK_config.h SYSTICK_interface.h SYSTICK_private.h SYSTICK_program.c AFIO_config.h AFIO_interface.h AFIO_private.h AFIO_program.c BIT_MATHS.h EXTI_config.h EXTI_interface.h EXTI_private.h EXTI_program.c GPIO_config.h GPIO_interface.h GPIO_private.h GPIO_program.c NVIC_config.h NVIC_interface.h NVIC_private.h NVIC_program.c LED.c LED.h
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.0
